FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-aarch64-Fix-sys-ptrace.h-if-linux-headers-are-includ.patch file://0002-Add-PTRACE_GET_RSEQ_CONFIGURATION-from-Linux-5.13-to.patch file://0003-nptl-Increase-default-TCB-alignment-to-32.patch file://0004-Use-__executable_start-as-the-lowest-address-for-pro.patch file://0005-csu-Always-use-__executable_start-in-gmon-start.c.patch file://0006-nptl-Add-thread_pointer.h-for-defining-__thread_poin.patch file://0007-x86_64-Correct-THREAD_SETMEM-THREAD_SETMEM_NC-for-mo.patch file://0008-nptl-Introduce-tcb-access.h-for-THREAD_-accessors.patch file://0009-nptl-Introduce-THREAD_GETMEM_VOLATILE.patch file://0010-elf-Introduce-__tls_init_tp-for-second-phase-TCB-ini.patch file://0011-nptl-Move-part-of-TCB-initialization-from-libpthread.patch file://0012-nptl-__nptl_set_robust_list_avail-must-be-nocommon.patch file://0013-nptl-Add-rseq-registration.patch file://0014-Linux-Use-rseq-to-accelerate-sched_getcpu.patch file://0015-nptl-Add-glibc.pthread.rseq-tunable-to-control-rseq-.patch file://0016-nptl-Add-public-rseq-symbols-and-sys-rseq.h.patch file://0017-nptl-rseq-failure-after-registration-on-main-thread-.patch file://0018-Remove-TLS_TCB_ALIGN-and-TLS_INIT_TCB_ALIGN.patch file://0019-Linux-Use-ptrdiff_t-for-__rseq_offset.patch file://0020-Fix-backport-include-nptl-pthreadP.h-from-csu-libc-t.patch"

